# Keil uVision project arm2131.uvproj, settings and files
target ARM2131 (ARM-ADS)
  device: LPC2131 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: arm2131 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group boot
    ../src/: Startup.s main.c
